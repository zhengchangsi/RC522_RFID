# Keil uVision project RC522_RFID_READ.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: RC522_RFID_READ +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./Source/: RC522_RFID_READ.c beep.c ctrl.c lcd12864.c rc522.c timer.c uart.c
